# Keil uVision project dg_test_full_clk.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: dg_test_full_clk +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: code clk.a51
